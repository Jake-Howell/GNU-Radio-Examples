options:
  parameters:
    generate_options: qt_gui
    id: Text_File_to_Unipolar_Line_Code
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    comment: |-
      Convert from 
      Char to Float
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    comment: Print output to terminal
    file: /dev/stdout
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Tx_File.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    comment: |-
      Byte to Serial Bit Conversion:
      [LSB first]
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    comment: |-
      Limit processing to 
      sample rate
    samples_per_second: baudrate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Display Output in time domain.

      Params changed:

      Genral->Y min:- -0.2
      Genral->Y max:- 1.2
      Config -> Control Panel:- Yes
      Config -> Stem Plot:- Yes
      Config -> Line Lable:- Baseband Signal
      Config -> Line Marker:- Circle
      Trigger-> Trigger Mode:- Normal
      Trigger-> Trigger Level:- 0.5
    ctrlpanel: 'True'
    grid: 'True'
    label1: Baseband Signal
    marker1: '0'
    size: '144'
    srate: baudrate
    stemplot: 'True'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"Start"'
    type: float
    update_time: '0.1'
    ymax: '1.2'
    ymin: '-0.2'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
